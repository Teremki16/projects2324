#include <GameBoy.h>
GameBoy gb;

byte zero[8][8] = {
{0, 0, 0, 0, 0, 0, 0, 0},
{0, 0, 1, 1, 1, 1, 0, 0},
{0, 0, 1, 0, 0, 1, 0, 0},
{0, 0, 1, 0, 0, 1, 0, 0},
{0, 0, 1, 0, 0, 1, 0, 0},
{0, 0, 1, 0, 0, 1, 0, 0},
{0, 0, 1, 1, 1, 1, 0, 0},
{0, 0, 0, 0, 0, 0, 0, 0},
};

byte one[8][8] = {
{0, 0, 0, 0, 0, 0, 0, 0},
{0, 0, 0, 0, 0, 1, 0, 0},
{0, 0, 0, 0, 1, 1, 0, 0},
{0, 0, 0, 0, 0, 1, 0, 0},
{0, 0, 0, 0, 0, 1, 0, 0},
{0, 0, 0, 0, 0, 1, 0, 0},
{0, 0, 0, 0, 1, 1, 1, 0},
{0, 0, 0, 0, 0, 0, 0, 0},
};

byte two[8][8] = {
{0, 0, 0, 0, 0, 0, 0, 0},
{0, 0, 1, 1, 1, 1, 0, 0},
{0, 0, 0, 0, 0, 1, 0, 0},
{0, 0, 1, 1, 1, 1, 0, 0},
{0, 0, 1, 0, 0, 0, 0, 0},
{0, 0, 1, 0, 0, 0, 0, 0},
{0, 0, 1, 1, 1, 1, 0, 0},
{0, 0, 0, 0, 0, 0, 0, 0},
}

void setup() {
  gb.begin(8);
}
int a = 0;
void loop(){
  if(gb.getKey() == 4){
    a--;
    delay(100);
  }
   if(gb.getKey() == 5){
    a++;
    delay(100);
   }
  if(a == 0){
   for(int i = 0; i < 8; i++){
    for(int j = 0; j < 8; j++){
     db.setLed(i,j, zero[j][i]);
   }
  }
 }
}
if(a == 1){
   for(int i = 0; i < 8; i++){
    for(int j = 0; j < 8; j++){
     db.setLed(i,j, one[j][i]);
   }
  }
 }
if(a == 2){
   for(int i = 0; i < 8; i++){
    for(int j = 0; j < 8; j++){
     db.setLed(i,j, two[j][i]);
   }
  }
 }
